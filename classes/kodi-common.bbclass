# Variables

KODICODENAME ?= "Omega"

# Default to GBM everywhere, sucks to be nvidia

KODIGRAPHICALBACKEND ?= "wayland"

# Autostart

KODISYSTEMDAUTOSTART ?= "enable"
