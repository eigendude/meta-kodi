FILES_${PN} += "${libdir}/libtinyxml.so \
    ${libdir}/libtinyxml.so.${PV} \
"
